# Keil uVision project tensortiger.uvprojx, settings and files
target LandTiger (6150000::V6.15::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tensortiger
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARM_MATH_CM3 CMSIS_NN SIMULATOR
  c include: .;third_party/gemmlowp;third_party/flatbuffers/include;third_party/ruy;third_party/kissfft;.\CMSIS\Core\Include;.\CMSIS\DSP\Include;.\CMSIS\NN\Include;.\CMSIS\NN\Source
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./: startup_LPC17xx.s
  group main
    ./: main.c
  group lib_SoC_board
    ./: core_cm3.c system_LPC17xx.c
  group GLCD
    ./GLCD/: AsciiLib.c GLCD.c
  group TouchPanel
    ./TouchPanel/: TouchPanel.c
  group timer
    ./timer/: IRQ_timer.c lib_timer.c
  group tensortiger
    ./: tensortiger.c
  group tensorflow
    ./tensorflow/lite/c/: common.c builtin_op_data.h c_api_types.h common.h
    ./tensorflow/lite/core/api/: tensor_utils.h tensor_utils.cc op_resolver.h op_resolver.cc flatbuffer_conversions.h flatbuffer_conversions.cc error_reporter.h error_reporter.cc
    ./tensorflow/lite/kernels/: kernel_util.cc kernel_util.h op_macros.h padding.h
    ./tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h portable_tensor.h quantization_util.cc quantization_util.h strided_slice_logic.h tensor_ctypes.h types.h
    ./tensorflow/lite/kernels/internal/optimized/: neon_check.h
    ./tensorflow/lite/kernels/internal/reference/: add.h add_n.h arg_min_max.h batch_to_space_nd.h binary_function.h ceil.h comparisons.h concatenation.h conv.h cumsum.h depth_to_space.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h elu.h exp.h fill.h floor.h floor_div.h floor_mod.h fully_connected.h hard_swish.h l2normalization.h leaky_relu.h log_softmax.h logistic.h maximum_minimum.h mul.h neg.h pad.h pooling.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_bilinear.h resize_nearest_neighbor.h round.h softmax.h space_to_batch_nd.h strided_slice.h sub.h tanh.h transpose.h transpose_conv.h
    ./tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h fully_connected.h l2normalization.h logistic.h mean.h mul.h pooling.h tanh.h transpose_conv.h
    ./tensorflow/lite/schema/: schema_generated.h schema_utils.cc schema_utils.h
    ./tensorflow/lite/: portable_type_to_tflitetype.h
    ./tensorflow/lite/micro/: all_ops_resolver.cc all_ops_resolver.h compatibility.h debug_log.cc debug_log.h memory_helpers.cc memory_helpers.h micro_allocator.cc micro_allocator.h micro_error_reporter.cc micro_error_reporter.h micro_graph.cc micro_graph.h micro_interpreter.cc micro_interpreter.h micro_mutable_op_resolver.h micro_op_resolver.h micro_profiler.cc micro_profiler.h micro_string.cc micro_string.h micro_time.cc micro_time.h micro_utils.cc micro_utils.h mock_micro_graph.cc mock_micro_graph.h recording_micro_allocator.cc recording_micro_allocator.h recording_micro_interpreter.h recording_simple_memory_allocator.cc recording_simple_memory_allocator.h simple_memory_allocator.cc simple_memory_allocator.h system_setup.cc system_setup.h test_helpers.cc test_helpers.h
    ./tensorflow/lite/micro/benchmarks/: keyword_scrambled_model_data.h
    ./tensorflow/lite/micro/examples/hello_world/: constants.cc constants.h main_functions.cc main_functions.h model.cc model.h output_handler.cc output_handler.h
    ./tensorflow/lite/micro/kernels/: activation_utils.h activations.cc add_n.cc arg_min_max.cc batch_to_space_nd.cc cast.cc ceil.cc circular_buffer.cc circular_buffer_flexbuffers_generated_data.h comparisons.cc concatenation.cc conv.h conv_common.cc conv_test.h cumsum.cc depth_to_space.cc depthwise_conv.h depthwise_conv_common.cc dequantize.cc detection_postprocess.cc detection_postprocess_flexbuffers_generated_data.h elementwise.cc elu.cc ethosu.cc ethosu.h exp.cc expand_dims.cc fill.cc floor.cc floor_div.cc floor_mod.cc fully_connected.h fully_connected_common.cc gather.cc gather_nd.cc hard_swish.cc if.cc kernel_runner.cc kernel_runner.h kernel_util.cc kernel_util.h l2_pool_2d.cc l2norm.cc leaky_relu.cc log_softmax.cc logical.cc logistic.cc maximum_minimum.cc micro_ops.h micro_utils.h neg.cc pack.cc pad.cc prelu.cc quantize.cc quantize.h quantize_common.cc reduce.cc reshape.cc resize_bilinear.cc resize_nearest_neighbor.cc round.cc shape.cc softmax.h softmax_common.cc space_to_batch_nd.cc split.cc split_v.cc squeeze.cc strided_slice.cc sub.cc svdf.h svdf_common.cc tanh.cc transpose.cc transpose_conv.cc unpack.cc zeros_like.cc
    ./tensorflow/lite/micro/kernels/cmsis_nn/: add.cc conv.cc depthwise_conv.cc fully_connected.cc mul.cc pooling.cc softmax.cc svdf.cc
    ./tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc greedy_memory_planner.h linear_memory_planner.cc linear_memory_planner.h memory_planner.h
    ./tensorflow/lite/micro/testing/: micro_test.h test_conv_model.h
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_armv81mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm3.h core_cm4.h core_cm7.h core_cm23.h core_cm33.h core_cm35p.h core_cm55.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/DSP/Include/: arm_common_tables.h arm_helium_utils.h arm_math.h arm_math_memory.h arm_math_types.h
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/DSP/Include/dsp/: basic_math_functions.h bayes_functions.h complex_math_functions.h controller_functions.h distance_functions.h fast_math_functions.h filtering_functions.h interpolation_functions.h matrix_functions.h none.h statistics_functions.h support_functions.h svm_defines.h svm_functions.h transform_functions.h utils.h
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Include/: arm_nn_tables.h arm_nn_types.h arm_nnfunctions.h arm_nnsupportfunctions.h
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q7.c arm_nn_activations_q15.c arm_relu_q7.c arm_relu_q15.c arm_relu6_s8.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_add_s8.c arm_elementwise_mul_s8.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1_x_n_s8.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_s8.c arm_convolve_wrapper_s8.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_kernel_s8_s16_reordered.c arm_nn_mat_mult_s8.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_s8.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_accumulate_q7_to_q15.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mult_q7.c arm_nn_mult_q15.c arm_nn_vec_mat_mult_t_s8.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_reordered_with_offset.c arm_q7_to_q15_with_offset.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/PoolingFunctions/: arm_avgpool_s8.c arm_max_pool_s8.c arm_pool_q7_HWC.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/SVDFunctions/: arm_svdf_s8.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_q7.c arm_softmax_q15.c arm_softmax_s8.c arm_softmax_u8.c arm_softmax_with_batch_q7.c
    ./: stdout_user.c
    ./third_party/flatbuffers/include/flatbuffers/: base.h flatbuffers.h flexbuffers.h stl_emulation.h util.h
    ./third_party/gemmlowp/fixedpoint/: fixedpoint.h fixedpoint_neon.h fixedpoint_sse.h
    ./third_party/gemmlowp/internal/: detect_platform.h
    ./third_party/ruy/ruy/profiler/: instrumentation.h
  group icons
    ./icons/: polito.c
software components: Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
